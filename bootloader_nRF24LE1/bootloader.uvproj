# Keil uVision project bootloader.uvproj, settings and files
target Bootloader (MCS-51)
  device: nRF24LE1 Nordic Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM(0x0000-0x03FF) XRAM2(0xFA00-0xFFFF) CLOCK(24000000) MODC2 MDU_R515
  output: bootloader +hex
  c flags: Optimize=9
  c define: DEBUG_LED_
  c include: C:\Nordic Semiconductor\nRFgo SDK 2.3.0.10040\source_code\hal\nrf24l01p;C:\Nordic Semiconductor\nRFgo SDK 2.3.0.10040\source_code\hal\nrf24le1;C:\Nordic Semiconductor\nRFgo SDK 2.3.0.10040\source_code\compiler\c51;C:\Nordic Semiconductor\nRFgo SDK 2.3.0.10040\source_code\compiler\common;C:\Nordic Semiconductor\nRFgo SDK 2.3.0.10040\source_code\hal\
  link misc: REMOVEUNUSED
  group SRC
    ./: STARTUP.A51 main.c
  group HAL
    C:/Nordic Semiconductor/nRFgo SDK 2.3.0.10040/source_code/hal/nrf24l01p/: hal_nrf.c
    C:/Nordic Semiconductor/nRFgo SDK 2.3.0.10040/source_code/hal/nrf24le1/: hal_nrf_hw.c hal_flash.c hal_clk.c
