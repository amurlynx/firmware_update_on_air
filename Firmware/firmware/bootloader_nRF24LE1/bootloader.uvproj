# Keil uVision project bootloader.uvproj, settings and files
target Bootloader (MCS-51)
  device: nRF24LE1 Nordic Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM(0x0000-0x03FF) XRAM2(0xFA00-0xFFFF) CLOCK(24000000) MODC2 MDU_R515
  output: bootloader +hex
  c flags: Optimize=9
  c define: DEBUG_LED_
  c include: ..\..\..\..\hal;..\..\..\..\hal\nrf24l01p;..\..\..\..\hal\nrf24le1;..\..\..\..\compiler\c51;..\..\..\..\compiler\common;..\common
  link misc: REMOVEUNUSED
  group SRC
    ./: STARTUP.A51 main.c
  group HAL
    ../../../../hal/nrf24le1/: hal_flash.c hal_clk.c hal_nrf_hw.c
    ../../../../hal/nrf24l01p/: hal_nrf.c
