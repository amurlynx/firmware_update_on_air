# Keil uVision project test_lcd.uvproj, settings and files
target Target 1 (MCS-51)
  device: nRF24LE1 Nordic Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM(0x0000-0x03FF) XRAM2(0xFA00-0xFFFF) CLOCK(24000000) MODC2 MDU_R515
  output: test_lcd
  c flags: Optimize=8 SizeSpeed=1
  c include: .\NRF24LE1_client-master\include;.\src
  group Source Group 1
    ./: STARTUP.A51 main.c
