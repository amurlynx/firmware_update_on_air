# Keil uVision project reciver.uvproj, settings and files
target reciver (MCS-51)
  device: nRF24LE1 Nordic Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM(0x0000-0x03FF) XRAM2(0xFA00-0xFFFF) CLOCK(24000000) MODC2 MDU_R515
  output: reciver +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: MCU_NRF24LE1
  c include: C:\Nordic Semiconductor\nRFgo SDK 2.3.0.10040\source_code\hal\nrf24l01p;C:\Nordic Semiconductor\nRFgo SDK 2.3.0.10040\source_code\hal\nrf24le1;C:\Nordic Semiconductor\nRFgo SDK 2.3.0.10040\source_code\compiler\c51;C:\Nordic Semiconductor\nRFgo SDK 2.3.0.10040\source_code\compiler\common;C:\Nordic Semiconductor\nRFgo SDK 2.3.0.10040\source_code\hal\
  group App
    ./: main.c
  group hal
    C:/Nordic Semiconductor/nRFgo SDK 2.3.0.10040/source_code/hal/: hal_delay.c
    C:/Nordic Semiconductor/nRFgo SDK 2.3.0.10040/source_code/hal/nrf24le1/: hal_uart.c hal_clk.c hal_nrf_hw.c
    C:/Nordic Semiconductor/nRFgo SDK 2.3.0.10040/source_code/hal/nrf24l01p/: hal_nrf.c
